File: hardware/outputs.sch (KiCad schematic (older format))
At the start: 40 parts

Commit message: sheets are named, global circuit is done.
Parts:
- gave numbers to parts that had none: 36
